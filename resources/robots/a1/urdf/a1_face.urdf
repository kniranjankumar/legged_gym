Commit message: RAL resubmission +two leg balance

File: resources/robots/a1/urdf/a1_face.urdf (robot description, URDF)
Before this commit: robot a1_description, 24 links, 23 joints
Links:
- link face: mass 0.001 -> 1
